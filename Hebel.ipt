# Autodesk Inventor part: Hebel
## iProperties
Created: 2009-02
Part Number: Hebel
Document SubType Name: Modeling
Designer: Alex
Density: 1 g/cm^3
Author: Alex
